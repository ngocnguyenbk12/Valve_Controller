# Keil uVision project SwitchOnOff_slave_enhanced_232_OTA_ZW050x_US_TI.uvproj, settings and files
target SwitchOnOff_slave_enhanced_232_OTA_ZW050x_US_TI (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: SwitchOnOff_slave_enhanced_232_OTA_ZW050x_US_TI.aof
  BeforeMake: C:/SDK/Tools/Make/make  --no-print-directory -- CHIP=ZW050x SENSOR_TYPE=NON_BATT RF=US COUNTRY=US LIB=slave_enhanced_232 TEST_INTERFACE=YES BOOTLOADER_ENABLED=1  BOOT=BOOTLOADER_ENABLED FREQUENCY=US UVISIONPREBUILD=1 WATCHDOG=WATCHDOG_DISABLED BUILDDIR=build_prj ZW0x0x
  AfterMake: C:/SDK/Tools/Make/make  --no-print-directory -- CHIP=ZW050x SENSOR_TYPE=NON_BATT RF=US COUNTRY=US LIB=slave_enhanced_232 TEST_INTERFACE=YES BOOTLOADER_ENABLED=1  BOOT=BOOTLOADER_ENABLED FREQUENCY=US UVISIONPOSTBUILD=1 WATCHDOG=WATCHDOG_DISABLED BUILDDIR=build_prj ZW0x0x
  c flags: Optimize=12
  c define: BOOTLOADER_ENABLED , slave_enhanced_232 , US, ZAF_BUILD_NO=52445 , ZW_SECURITY_PROTOCOL , ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, ZW0501, NEW_NODEINFO, ZW_SELF_HEAL , BANKING , TEST_INTERFACE_SUPPORT, ZW_TEST_INTERFACE_DRIVER , NON_BATT, ZW_SMARTSTART_ENABLED
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_TI_RELS;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_TI;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER;..\Valve_fucntion
  asm include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_TI_RELS;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_TI;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ./: App_RFSetup.c
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
  group Z-Wave Lib (BANK1 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2CRYPTO.LIB
  group Z-Wave Lib (BANK3 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB LIBS2CRYPTO.LIB
  group Appl Source Code (BANK1)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK1_MARK.C
  group Appl Source Code (BANK2)
    ./: SwitchOnOff.c eeprom.c
    ../APPLICATIONUTILITIES/: ZW_NVM_DESCRIPTOR.C ZW_NVR_APP_API.C IO_ZDP03A.C GPIO_DRIVER.C ZW_STRING.C ASSOCIATION_PLUS.C AGI.C ZW_TASK.C ZW_UTIL_QUEUE.C EV_MAN.C OTA_UTIL.C NVM_UTIL.C ZW_TRANSPORTMULTICAST.C ZW_TRANSPORTENDPOINT.C ZW_TRANSPORTSECPROTOCOL.C ZW_CMD_CLASS_LIST.C ENDPOINT_LOOKUP.C ZW_TEST_INTERFACE.C ZW_FIRMWARE_BANK2_MARK.C
    ../APPLICATIONCOMMANDHANDLERS/: COMMANDCLASS.C COMMANDCLASSVERSION.C COMMANDCLASSPOWERLEVEL.C COMMANDCLASSDEVICERESETLOCALLY.C COMMANDCLASSASSOCIATION.C COMMANDCLASSASSOCIATIONGROUPINFO.C COMMANDCLASSMANUFACTURERSPECIFIC.C COMMANDCLASSZWAVEPLUSINFO.C COMMANDCLASSBASIC.C COMMANDCLASSBINARYSWITCH.C COMMANDCLASSFIRMWAREUPDATE.C ZW_TX_MUTEX.C COMMANDCLASSMULTICHAN.C COMMANDCLASSMULTICHANASSOCIATION.C COMMANDCLASSSUPERVISION.C
    ../Valve_fucntion/: conhandle.c key.c CommandClassConfiguration.c CommandClassAllSwitch.c Cat25256.c CommandClassMeter.c
    ../ApplicationUtilities/: key_driver.c notification.c
    ../ApplicationCommandHandlers/: CommandClassNotification.c
  group Appl Source Code (BANK3)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK3_MARK.C
  group Appl Source Code (COMMON)
    ../APPLICATIONUTILITIES/: INTERRUPT_DRIVER.C ZW_TEST_INTERFACE_DRIVER.C ZW_FIRMWARE_DESCRIPTOR_ADDR.C ZW_FIRMWARE_DESCRIPTOR.C
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 ZW_APP_VERSION.A51
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    C:/KEIL_V5/C51//LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_US.OBJ
  group Z-Wave Inc
    ../../Z-WAVE/INCLUDE/: ZW_TYPEDEFS.H ZW_CLASSCMD.H ZW_STDINT.H ZW_TRANSPORT_API.H ZW_SECURITY_API.H ZW_NODEMASK_API.H ZW_MEM_API.H ZW_UART_API.H ZW_SYSDEFS.H ZW0X0X.H ZW050X.H ZW_RF050X.H ZW_BASIS_API.H ZW_TIMER_API.H ZW_NVM_DESCRIPTOR.H ZW_CRC.H ZW_FIRMWARE_DESCRIPTOR.H ZW_FIRMWARE_BOOTLOADER_DEFS.H ZW_NVM_EXT_API.H ZW_FIRMWARE_UPDATE_NVM_API.H ZW_NVR_API.H ZW_NON_ZERO.H ZW_SLAVE_32_API.H ZW_SLAVE_ROUTING_API.H ZW_SLAVE_API.H ZW_POWER_API.H ZW_OTA_COMPRESSION_HEADER.H ZW_FLASH_API.H CONFIG_LIB.H
    ./: CONFIG_APP.H EEPROM.H APP_VERSION.H
    ../APPLICATIONUTILITIES/: ZW_PRODUCT_ID_ENUM.H ZW_TRANSPORTENDPOINT.H APP_CONFIG_COMMON.H ZW_STRING.H ASSOCIATION_PLUS.H AGI.H MISC.H ZW_TRANSPORTLAYER.H ZW_TRANSPORTMULTICAST.H ZW_TRANSPORTSECPROTOCOL.H OTA_UTIL.H ZW_CMD_CLASS_LIST.H ZW_NVR_APP_API.H SDK_VERSION.H ZAF_VERSION.H ENDPOINT_LOOKUP.H EV_MAN.H ZW_TASK.H ZW_UTIL_QUEUE_API.H GPIO_DRIVER.H INTERRUPT_DRIVER.H IO_ZDP03A.H KEY_DRIVER.H APPL_TIMER_API.H ZW_TEST_INTERFACE.H ZAF_PM.H NVM_UTIL.H ZW_TEST_INTERFACE_DRIVER.H
    ../APPLICATIONCOMMANDHANDLERS/: COMMANDCLASSMANUFACTURERSPECIFIC.H ZW_TX_MUTEX.H COMMANDCLASS.H COMMANDCLASSASSOCIATIONGROUPINFO.H COMMANDCLASSASSOCIATION.H COMMANDCLASSBASIC.H COMMANDCLASSBINARYSWITCH.H COMMANDCLASSDEVICERESETLOCALLY.H COMMANDCLASSFIRMWAREUPDATE.H COMMANDCLASSVERSION.H COMMANDCLASSMULTICHAN.H COMMANDCLASSMULTICHANASSOCIATION.H COMMANDCLASSPOWERLEVEL.H COMMANDCLASSSUPERVISION.H COMMANDCLASSZWAVEPLUSINFO.H ZW_PLUS_VERSION.H COMMANDCLASSWAKEUP.H
    ../../Z-WAVE/IO_DEFINES/: ZW_PINDEFS.H ZW_EVALDEFS.H
    C:/KEIL_V5/C51/INC/: INTRINS.H

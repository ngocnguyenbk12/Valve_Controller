# Keil uVision project serialapi_slave_enhanced_232_OTW_ZW050x_US.uvproj, settings and files
target serialapi_slave_enhanced_232_OTW_ZW050x_US (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: serialapi_slave_enhanced_232_OTW_ZW050x_US.aof
  BeforeMake: C:/SDK/Tools/Make/make  --no-print-directory -- SENSOR_TYPE=NON_BATT RF=US COUNTRY=US LIB=slave_enhanced_232 BOOTLOADER_ENABLED=1  BOOT=BOOTLOADER_ENABLED HOST_INTERFACE=UART BOARD=ZM5202 CHIP=ZW050x FREQUENCY=US UVISIONPREBUILD=1 WATCHDOG=WATCHDOG_DISABLE LIBRARY=slave_enhanced_232 BUILDDIR=build_prj ZW0x0x
  AfterMake: C:/SDK/Tools/Make/make  --no-print-directory -- SENSOR_TYPE=NON_BATT RF=US COUNTRY=US LIB=slave_enhanced_232 BOOTLOADER_ENABLED=1  BOOT=BOOTLOADER_ENABLED HOST_INTERFACE=UART BOARD=ZM5202 CHIP=ZW050x FREQUENCY=US UVISIONPOSTBUILD=1 WATCHDOG=WATCHDOG_DISABLE LIBRARY=slave_enhanced_232 BUILDDIR=build_prj ZW0x0x
  c flags: Optimize=12
  c define: BOOTLOADER_ENABLED , slave_enhanced_232 , US, ZAF_BUILD_NO=52445 , ZW_SECURITY_PROTOCOL , ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, ZW0501, NEW_NODEINFO, ZW_SELF_HEAL , BANKING , ZW_ID_SERVER, SUC_SUPPORT, SERIAL_API_APP , ZW_SMARTSTART_ENABLED, ZW_EXPLORE , ENABLE_LEDS , NON_BATT
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SERIALAPI_SLAVE_ENHANCED_232_OTW_ZW050X_RELS;.\BUILD_PRJ\SERIALAPI_SLAVE_ENHANCED_232_OTW_ZW050X;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER
  asm include: as above
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ./: App_RFSetup.c
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
  group Z-Wave Lib (BANK1 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2CRYPTO.LIB
  group Z-Wave Lib (BANK3 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB LIBS2CRYPTO.LIB
  group Appl Source Code (BANK1)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK1_MARK.C
  group Appl Source Code (BANK2)
    ./: serialappl.c conhandle.c eeprom.c nvmHost.c
    ../APPLICATIONUTILITIES/: LED_CONTROL.C ZW_NVR_APP_API.C ZW_CMD_CLASS_LIST.C ZW_TRANSPORTSECPROTOCOL.C ZW_NVM_DESCRIPTOR.C ZW_FIRMWARE_BANK2_MARK.C
  group Appl Source Code (BANK3)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK3_MARK.C
  group Appl Source Code (COMMON)
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 ZW_APP_VERSION.A51
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_DESCRIPTOR_ADDR.C ZW_FIRMWARE_DESCRIPTOR.C
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    C:/KEIL_V5/C51//LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_US.OBJ
  group Z-Wave Inc
    ../../Z-WAVE/INCLUDE/: ZW_RF050X.H ZW_BASIS_API.H ZW_TYPEDEFS.H ZW_SYSDEFS.H ZW0X0X.H ZW050X.H ZW_STDINT.H ZW_TRANSPORT_API.H ZW_SECURITY_API.H ZW_NODEMASK_API.H ZW_TIMER_API.H ZW_MEM_API.H ZW_CLASSCMD.H ZW_UART_API.H ZW_SERIALAPI.H ZW_CONBUFIO.H ZW_SLAVE_API.H ZW_NVM_DESCRIPTOR.H CONFIG_LIB.H ZW_SLAVE_32_API.H ZW_SLAVE_ROUTING_API.H ZW_POWER_API.H ZW_FLASH_API.H ZW_NVR_API.H ZW_AES_API.H ZW_PORTPIN_API.H ZW_NVM_EXT_API.H ZW_FIRMWARE_UPDATE_NVM_API.H ZW_FIRMWARE_BOOTLOADER_DEFS.H ZW_FIRMWARE_DESCRIPTOR.H
    ./: CONHANDLE.H EEPROM.H SERIALAPPL.H CONFIG_APP.H NVMHOST.H APP_VERSION.H
    ./BUILD_PRJ/SERIALAPI_SLAVE_ENHANCED_232_OTW_ZW050X_RELS/: LIB_SUPPORTED_FUNC.H
    ./BUILD_PRJ/: SLAVE_ENHANCED_232_SUPPORTED_FUNC.H
    ../APPLICATIONUTILITIES/: ZW_PRODUCT_ID_ENUM.H ZW_TRANSPORTSECPROTOCOL.H ZW_TRANSPORTENDPOINT.H LED_CONTROL.H ZAF_VERSION.H ZW_TRANSPORTLAYER.H ZW_TRANSPORTMULTICAST.H ZW_NVR_APP_API.H ZW_CMD_CLASS_LIST.H MISC.H
    ../APPLICATIONCOMMANDHANDLERS/: ZW_TX_MUTEX.H COMMANDCLASS.H COMMANDCLASSASSOCIATION.H
    ../../Z-WAVE/IO_DEFINES/: ZW_PINDEFS.H ZW_EVALDEFS.H
